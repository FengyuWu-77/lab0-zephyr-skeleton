## apps/nordic_blinky/tests/BME280_DT_TEST/testcase.yaml
```yaml
tests:
  bme280.dt:
    platform_allow:
      - qemu_cortex_m3
    tags:
      - bme280
      - devicetree
    harness: ztest
```
